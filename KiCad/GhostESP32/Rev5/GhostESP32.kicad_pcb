# Repository krootee/Ghost (continued)

## KiCad design KiCad/GhostSensorboard/Rev2/GhostSensorboard.kicad_pcb

Parts:
C1: 0.1uF; C_0603
C2: 1nF; C_0603
D1: LED; LED_0805
J2: CONN_02X20; hrs-fx8c-40s-sv5
P1: StartModule; Pin_Header_Straight_1x03_Pitch2.54mm
P2: SteeringServo; Pin_Header_Straight_1x03_Pitch2.54mm
P3: Motor; Pin_Header_Straight_1x03_Pitch2.54mm
Q1, Q2: BSS138; SOT-23
R1, R9, R10, R11: 2k2; R_0402
R2: 100; R_0402
R3, R6, R7, R8, R15: 10k; R_0402
R4: 470; R_0402
R5: 330; R_0402
R14: 270; R_0402
SW1: SW_Push; SW_SPST_EVQP2
U4: TSOP753; TSOP75x
U5: Transmissive_Photo_Interrupter; Pin_Header_Straight_1x04_Pitch2.54mm

Connections:
+3V3: J2.7, J2.8, J2.9, J2.10, Q1.1 (G), Q2.1 (G), R1.1, R2.2, R3.1, R5.2, R7.1, R9.1, R10.1, R11.1; also elsewhere on the board
+5V: J2.35, J2.36, J2.37, J2.38, J2.39, J2.40, P2.2, P3.2, R6.1, R8.1, R14.2, R15.1
BUTTON: J2.25, R4.2
ENCODER: J2.24, R15.2, U5.3 (COLLECTOR)
GND: C1.2, C2.1, J2.13, J2.14, J2.15, J2.16, J2.17, J2.18, J2.19, J2.20, P1.2, P2.3, P3.3, SW1.2, U4.1 (GND), U4.4 (GND), U5.2 (CATHODE), U5.4 (EMITTER); also elsewhere on the board
IO13: J2.33, R11.2; also elsewhere on the board
IO14: J2.34, R1.2; also elsewhere on the board
IO17: J2.26, P1.1
IO22: J2.22, U4.3 (OUT)
IO25: J2.3, P1.3
IO26: J2.2, Q1.2 (S), R3.2
IO27: J2.1, Q2.2 (S), R7.2
IO32: J2.5, R9.2; also elsewhere on the board
IO33: J2.4, R10.2; also elsewhere on the board
LED: D1.1 (K), J2.21
MOTOR_5V_PWM: P3.1, Q2.3 (D), R8.2
unnamed: C1.1, R2.1, U4.2 (VS)
unnamed: C2.2, R4.1, SW1.1
unnamed: D1.2 (A), R5.1
unnamed: R14.1, U5.1 (ANODE)
STEERING_5V_PWM: P2.1, Q1.3 (D), R6.2

Notes on the sheet:
Ghost Sensorboard
A shield for the Ghost32 board. Contains sensors and connectors.
NB, GPIO pins from ESP is 3.3V level!
Startmodule Use a female 3pin header. Accepts both 3V3 and 5V. Power is supplied via GPIO, so that recycle can be done via software.
SteeringServo PWM signal has been levelshifted from 3V3 to 5V logic.
Motor This is where 5V is supplied to the system! PWM signal has been levelshifted from 3V3 to 5V logic.
Level shifting IO signals from 3V3 to 5V.
General purpose switch. Use internal pull-up resistor in ESP32.
Infrared Receiver, 38kHz (May optionally replace StartModule) TSOP75538WTR, Farnell no: 225-1430 (or similar) Voltage: 2.5-5.5V
Pull-up resistors for I2C channel 1
General purpose LED
Pull-up resistors for I2C channel 0
Encoder KTIR0611S
Bottom connector, 40 pin Hirose FX8C-40S-SV5 Farnell no: 249-8688
Mapping of ESP32 GPIO's to physical devices
NB, IO23 is dedicated to LED NB, IO32 (SCL) and IO33 (SDA) is dedicated to I2C

Parts:
R12, R13: 2k2; R_0402
RN1, RN2, RN3, RN4: R_Pack08; R_Array_Convex_8x0602
U1, U9: TCA9548ARGER; QFN-24_4x4mm_Pitch0.5mm
U2, U3, U7, U8, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21: GP2Y0E02B; JST_SH_BM04B-SRSS-TB_04x1.00mm_Straight

Connections:
+3V3: R12.1, R13.1, RN1.9 (R8.2), RN1.10 (R7.2), RN1.11 (R6.2), RN1.12 (R5.2), RN1.13 (R4.2), RN1.14 (R3.2), RN1.15 (R2.2), RN1.16 (R1.2), RN2.9 (R8.2), RN2.10 (R7.2), RN2.11 (R6.2), RN2.12 (R5.2), RN2.13 (R4.2), RN2.14 (R3.2), RN2.15 (R2.2), RN2.16 (R1.2), RN3.9 (R8.2), RN3.10 (R7.2), RN3.11 (R6.2), RN3.12 (R5.2), RN3.13 (R4.2), RN3.14 (R3.2), RN3.15 (R2.2), RN3.16 (R1.2), RN4.9 (R8.2), RN4.10 (R7.2), RN4.11 (R6.2), RN4.12 (R5.2), RN4.13 (R4.2), RN4.14 (R3.2), RN4.15 (R2.2), RN4.16 (R1.2), U1.21 (VCC), U2.4 (VDD), U3.4 (VDD), U7.4 (VDD), U8.4 (VDD), U9.21 (VCC), U9.22 (A0), U10.4 (VDD), U11.4 (VDD), U12.4 (VDD), U13.4 (VDD), U14.4 (VDD), U15.4 (VDD), U16.4 (VDD), U17.4 (VDD), U18.4 (VDD), U19.4 (VDD), U20.4 (VDD), U21.4 (VDD); also elsewhere on the board
GND: U1.9 (GND), U1.18 (A2), U1.22 (A0), U1.23 (A1), U2.3 (GND), U3.3 (GND), U7.3 (GND), U8.3 (GND), U9.9 (GND), U9.18 (A2), U9.23 (A1), U10.3 (GND), U11.3 (GND), U12.3 (GND), U13.3 (GND), U14.3 (GND), U15.3 (GND), U16.3 (GND), U17.3 (GND), U18.3 (GND), U19.3 (GND), U20.3 (GND), U21.3 (GND); also elsewhere on the board
IO13: U1.20 (SDA); also elsewhere on the board
IO14: U1.19 (SCL); also elsewhere on the board
IO32: U9.19 (SCL); also elsewhere on the board
IO33: U9.20 (SDA); also elsewhere on the board
unnamed: R12.2, U1.24 (~Reset)
unnamed: R13.2, U9.24 (~Reset)
SC0: RN1.7 (R7.1), U1.2 (SC0), U2.1 (SCL)
SC1: RN1.5 (R5.1), U1.4 (SC1), U3.1 (SCL)
SC2: RN1.3 (R3.1), U1.6 (SC2), U7.1 (SCL)
SC3: RN1.1 (R1.1), U1.8 (SC3), U8.1 (SCL)
SC4: RN2.7 (R7.1), U1.11 (SC4), U10.1 (SCL)
SC5: RN2.5 (R5.1), U1.13 (SC5), U11.1 (SCL)
SC6: RN2.3 (R3.1), U1.15 (SC6), U12.1 (SCL)
SC7: RN2.1 (R1.1), U1.17 (SC7), U13.1 (SCL)
SC8: RN4.3 (R3.1), U9.2 (SC0), U14.1 (SCL)
SC9: RN4.1 (R1.1), U9.4 (SC1), U15.1 (SCL)
SC10: RN3.8 (R8.1), U9.6 (SC2), U16.1 (SCL)
SC11: RN3.6 (R6.1), U9.8 (SC3), U17.1 (SCL)
SC12: RN3.4 (R4.1), U9.11 (SC4), U18.1 (SCL)
SC13: RN3.2 (R2.1), U9.13 (SC5), U19.1 (SCL)
SC14: RN4.7 (R7.1), U9.15 (SC6), U20.1 (SCL)
SC15: RN4.5 (R5.1), U9.17 (SC7), U21.1 (SCL)
SD0: RN1.8 (R8.1), U1.1 (SD0), U2.2 (SDA)
SD1: RN1.6 (R6.1), U1.3 (SD1), U3.2 (SDA)
SD2: RN1.4 (R4.1), U1.5 (SD2), U7.2 (SDA)
SD3: RN1.2 (R2.1), U1.7 (SD3), U8.2 (SDA)
SD4: RN2.8 (R8.1), U1.10 (SD4), U10.2 (SDA)
SD5: RN2.6 (R6.1), U1.12 (SD5), U11.2 (SDA)
SD6: RN2.4 (R4.1), U1.14 (SD6), U12.2 (SDA)
SD7: RN2.2 (R2.1), U1.16 (SD7), U13.2 (SDA)
SD8: RN4.4 (R4.1), U9.1 (SD0), U14.2 (SDA)
SD9: RN4.2 (R2.1), U9.3 (SD1), U15.2 (SDA)
SD10: RN3.7 (R7.1), U9.5 (SD2), U16.2 (SDA)
SD11: RN3.5 (R5.1), U9.7 (SD3), U17.2 (SDA)
SD12: RN3.3 (R3.1), U9.10 (SD4), U18.2 (SDA)
SD13: RN3.1 (R1.1), U9.12 (SD5), U19.2 (SDA)
SD14: RN4.8 (R8.1), U9.14 (SD6), U20.2 (SDA)
SD15: RN4.6 (R6.1), U9.16 (SD7), U21.2 (SDA)

Notes on the sheet:
Sharp GP2Y0E02B IR sensors I2C address: 0x80 Range 4-50 cm JST SH connectors, 4 pin, 1mm pitch
Pull-up resistors for the IR-sensors 8 x 1k ohm resistor network Farnell no: 137-7053
TCA9548ARGER I2C multiplexer I2C address: 0x70
TCA9548ARGER I2C multiplexer I2C address: 0x71

Board: 4 copper layers, 60.0 x 37.0 mm, 49 parts (1 on the bottom side), 55 nets.

## KiCad design KiCad/GhostConnectorBoard/GhostConnectorBoard.kicad_pcb

Parts:
R1, R2, R3, R4: 2k2; R_0603
RN1, RN2, RN3, RN4: R_Pack08; R_Array_Convex_8x0602
U1, U6: TCA9548ARGER; QFN-24_4x4mm_Pitch0.5mm
U2, U3, U4, U5, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18: GP2Y0E02B; JST_SH_BM04B-SRSS-TB_04x1.00mm_Straight

Connections:
+3V3: R1.1, R2.1, R3.1, R4.1, RN1.9 (R8.2), RN1.10 (R7.2), RN1.11 (R6.2), RN1.12 (R5.2), RN1.13 (R4.2), RN1.14 (R3.2), RN1.15 (R2.2), RN1.16 (R1.2), RN2.9 (R8.2), RN2.10 (R7.2), RN2.11 (R6.2), RN2.12 (R5.2), RN2.13 (R4.2), RN2.14 (R3.2), RN2.15 (R2.2), RN2.16 (R1.2), RN3.9 (R8.2), RN3.10 (R7.2), RN3.11 (R6.2), RN3.12 (R5.2), RN3.13 (R4.2), RN3.14 (R3.2), RN3.15 (R2.2), RN3.16 (R1.2), RN4.9 (R8.2), RN4.10 (R7.2), RN4.11 (R6.2), RN4.12 (R5.2), RN4.13 (R4.2), RN4.14 (R3.2), RN4.15 (R2.2), RN4.16 (R1.2), U1.21 (VCC), U2.4 (VDD), U3.4 (VDD), U4.4 (VDD), U5.4 (VDD), U6.21 (VCC), U6.22 (A0), U7.4 (VDD), U8.4 (VDD), U9.4 (VDD), U10.4 (VDD), U11.4 (VDD), U12.4 (VDD), U13.4 (VDD), U14.4 (VDD), U15.4 (VDD), U16.4 (VDD), U17.4 (VDD), U18.4 (VDD)
/GPIO_SCL_1: U6.19 (SCL)
/GPIO_SDA_1: U6.20 (SDA)
GND: U1.9 (GND), U1.18 (A2), U1.22 (A0), U1.23 (A1), U2.3 (GND), U3.3 (GND), U4.3 (GND), U5.3 (GND), U6.9 (GND), U6.18 (A2), U6.23 (A1), U7.3 (GND), U8.3 (GND), U9.3 (GND), U10.3 (GND), U11.3 (GND), U12.3 (GND), U13.3 (GND), U14.3 (GND), U15.3 (GND), U16.3 (GND), U17.3 (GND), U18.3 (GND)
GPIO_SCL_0: R4.2, U1.19 (SCL)
GPIO_SDA_0: R3.2, U1.20 (SDA)
unnamed: R1.2, U1.24 (~Reset)
unnamed: R2.2, U6.24 (~Reset)
SC0: RN1.2 (R2.1), U1.2 (SC0), U2.1 (SCL)
SC1: RN1.4 (R4.1), U1.4 (SC1), U3.1 (SCL)
SC2: RN1.6 (R6.1), U1.6 (SC2), U4.1 (SCL)
SC3: RN1.8 (R8.1), U1.8 (SC3), U5.1 (SCL)
SC4: RN2.2 (R2.1), U1.11 (SC4), U7.1 (SCL)
SC5: RN2.4 (R4.1), U1.13 (SC5), U8.1 (SCL)
SC6: RN2.6 (R6.1), U1.15 (SC6), U9.1 (SCL)
SC7: RN2.8 (R8.1), U1.17 (SC7), U10.1 (SCL)
SC8: RN3.2 (R2.1), U11.1 (SCL)
SC9: RN3.4 (R4.1), U12.1 (SCL)
SC10: RN3.6 (R6.1), U13.1 (SCL)
SC11: RN3.8 (R8.1), U14.1 (SCL)
SC12: RN4.2 (R2.1), U15.1 (SCL)
SC13: RN4.4 (R4.1), U16.1 (SCL)
SC14: RN4.6 (R6.1), U17.1 (SCL)
SC15: RN4.8 (R8.1), U18.1 (SCL)
SD0: RN1.1 (R1.1), U1.1 (SD0), U2.2 (SDA)
SD1: RN1.3 (R3.1), U1.3 (SD1), U3.2 (SDA)
SD2: RN1.5 (R5.1), U1.5 (SD2), U4.2 (SDA)
SD3: RN1.7 (R7.1), U1.7 (SD3), U5.2 (SDA)
SD4: RN2.1 (R1.1), U1.10 (SD4), U7.2 (SDA)
SD5: RN2.3 (R3.1), U1.12 (SD5), U8.2 (SDA)
SD6: RN2.5 (R5.1), U1.14 (SD6), U9.2 (SDA)
SD7: RN2.7 (R7.1), U1.16 (SD7), U10.2 (SDA)
SD8: RN3.1 (R1.1), U11.2 (SDA)
SD9: RN3.3 (R3.1), U12.2 (SDA)
SD10: RN3.5 (R5.1), U13.2 (SDA)
SD11: RN3.7 (R7.1), U14.2 (SDA)
SD12: RN4.1 (R1.1), U15.2 (SDA)
SD13: RN4.3 (R3.1), U16.2 (SDA)
SD14: RN4.5 (R5.1), U17.2 (SDA)
SD15: RN4.7 (R7.1), U18.2 (SDA)

Notes on the sheet:
Sharp GP2Y0E02B IR sensors I2C address: 0x80 Range 4-50 cm JST SH connectors, 4 pin, 1mm pitch
Pull-up resistors for the IR-sensors 8 x 1k ohm resistor network Farnell no: 137-7053
TCA9548ARGER I2C multiplexer I2C address: 0x70
TCA9548ARGER I2C multiplexer I2C address: 0x71
GHOST CONNECTORBOARD

Parts:
J1, J2: CONN_02X20; hrs-fx8c-40p-sv

Notes on the sheet:
TOP
BOTTOM

Board: 2 copper layers, 60.0 x 37.0 mm, 28 parts (1 on the bottom side), 38 nets.

## KiCad design KiCad/GhostESP32/Rev1/GhostESP32.kicad_pcb

Parts:
C1, C5, C8, C9: 10uF; C_0603
C2: 22uF; C_0603
C3, C10, C11: 1nF; C_0603
C4: 100uF; C_0603
C6: 1uF; C_0603
C7: 0.1uF; C_0603
D1: RED LED; LED_0603
D2: SSA33L Schottky; D_SMA_Standard
D3: TXLED; LED_0603
D4: RXLED; LED_0603
D5: LED; LED_0603
P1: USB_OTG; USB_Micro-B
P2: CONN_02X30; hrs-fx8c-60p-sv
Q1, Q2: Q_NPN_BEC
R1: 2K; R_0603
R2, R3, R9: 12K; R_0603
R4, R5: 0; R_0603
R6, R7: (NC); R_0603
R8, R10: 1k; R_0603
R11, R14, R15: 470; R_0603
R12, R13: 5K; R_0603
R16: 390; R_0603
SW1, SW2: SW_Push; SW_SPST_EVQP2
U1: MC33269; TO-252-2Lead
U2: LM358; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: CP2102; QFN-28-1EP_5x5mm_Pitch0.5mm
U4: ESP-WROOM-32; ESP32-WROOM

Connections:
+3V3: C2.1, C4.1, C5.1, C6.1, C7.1, P2.2, P2.3, P2.4, P2.5, R9.1, R13.2, U1.2 (VOUT), U2.8 (V+), U3.6 (VDD), U3.7 (REGIN), U4.2 (3V3)
+5V: C1.1, C8.1, C9.1, D2.1 (K), P2.7, P2.8, P2.9, P2.20, P2.21, P2.22, P2.23, P2.24, R1.1, U1.3 (VIN), U3.8 (VBUS)
CLK: P2.46, U4.20 (CLK)
CMD: P2.47, U4.19 (CMD)
CTS: R7.1, U3.23 (CTS)
DTR: Q2.2, R2.2, U3.28 (DTR)
EN: C3.1, Q1.3, R9.2, R15.1, U4.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, D1.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), P1.5 (GND), P1.6 (shield), P2.11, P2.12, P2.13, P2.14, P2.15, P2.16, P2.26, P2.27, P2.28, P2.29, P2.30, P2.41, R12.1, SW1.1, SW2.1, U1.1 (GND), U2.4 (V-), U3.3 (GND), U3.29 (GND), U4.1 (GND), U4.15 (GND), U4.38 (GND), U4.39 (GND-PAD); also elsewhere on the board
IO0: P2.40, Q2.3, R13.1, R14.1, U4.25 (IO0)
IO2: P2.42, R12.2, U4.24 (IO2)
IO4: P2.39, U4.26 (IO4)
IO5: P2.36, U4.29 (IO5)
IO12: P2.51, U4.14 (IO12)
IO13: R6.2, U4.16 (IO13)
IO14: P2.52, U4.13 (IO14)
IO15: P2.43, R7.2, U4.23 (IO15)
IO16: P2.38, U4.27 (IO16)
IO17: P2.37, U4.28 (IO17)
IO18: P2.35, U4.30 (IO18)
IO19: P2.34, U4.31 (IO19)
IO21: P2.33, U4.33 (IO21)
IO22: P2.32, U4.36 (IO22)
IO23: P2.31, R16.2, U4.37 (IO23)
IO25: P2.55, U4.10 (IO25)
IO26: P2.54, U4.11 (IO26)
IO27: P2.53, U4.12 (IO27)
IO32: P2.57, U4.8 (IO32)
IO33: P2.56, U4.9 (IO33)
IO34: P2.59, U4.6 (IO34)
IO35: P2.58, U4.7 (IO35)
unnamed: C10.1, R14.2, SW1.2
unnamed: C11.1, R15.2, SW2.2
unnamed 32: D1.2 (A), R1.2; also elsewhere on the board
unnamed: D2.2 (A), P1.1 (VBUS)
unnamed 34: D3.2 (A), R8.1; also elsewhere on the board
unnamed 35: D4.2 (A), R10.1; also elsewhere on the board
unnamed: D5.2 (A), R16.1
unnamed: Q1.1, R2.1
unnamed: Q2.1, R3.1
unnamed: R8.2, U2.1, U2.2 (-)
unnamed: R10.2, U2.6 (-), U2.7
unnamed: R11.1, U3.26 (TXD)
RTS: Q1.2, R3.2, R6.1, U3.24 (RTS)
RXD: R4.1, U2.5 (+), U3.25 (RXD)
RXD0: R5.2, U4.34 (RXD0)
SD0: P2.45, U4.21 (SD0)
SD1: P2.44, U4.22 (SD1)
SD2: P2.49, U4.17 (SD2)
SD3: P2.48, U4.18 (SD3)
SENSOR_VN: P2.60, U4.5 (SENSOR_VN)
SENSOR_VP: P2.1, U4.4 (SENSOR_VP)
TXD: R5.1, R11.2, U2.3 (+)
TXD0: R4.2, U4.35 (TXD0)
USB_DN: P1.2 (D-), U3.5 (D-)
USB_DP: P1.3 (D+), U3.4 (D+)
USB_SUSPEND: P2.18, U3.11 (~SUSPEND)

Notes on the sheet:
Ghost ESP32 shield
A shield based around the ESP-WROOM-32 It uses a stackable header from Hirose to connect to other boards. Board is powered by 5.0V either through MicroUSB, or via 60-pin connector.
Topside connector, 60 pin Hirose FX8C-60P-SV Farnell no: 249-8646
Only TWO resistors populated (the RX/TX pair)
(Not Connected)
MMBT2222A NPN transistors Farnell no: 177-3626
Generic LED
MicroUSB Farnell no: 156-8022/229-3836
MC33269DT-3.3G Farnel no: 165-2330 1.1V dropout, 800mA out
Note, pins 34 - 39 are INPUT mode ONLY. Note, pins 6-11 are used by SPI-flash, and cannot be used for other purposes.

Board: 2 copper layers, 50.0 x 50.0 mm, 42 parts (0 on the bottom side), 56 nets.

Other parts of the board:
POWER: RED LED; LED_0603
RX: RXLED; LED_0603
TX: TXLED; LED_0603

Their connections:
GND: POWER.1, RX.1, TX.1; also elsewhere on the board
unnamed 32: POWER.2; also elsewhere on the board
unnamed 34: TX.2; also elsewhere on the board
unnamed 35: RX.2; also elsewhere on the board
