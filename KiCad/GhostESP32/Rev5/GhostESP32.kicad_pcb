# Repository krootee/Ghost

File README.md:

# Ghost32

## Summary

Ghost32 is an autonomous car used for Folkrace robot competition. It uses a customized Losi 1/24-scale RTR 4WD Rally Car, and with a custom created PCB and various sensors. The "brain" of the car is an ESP32, and it is programmed using C++ and Mongoose OS.

This GitHub repository contains all relevant info for creating both hardware and software.

//More details about the project can be found on http://scalpel78.github.io/Ghost/

## KiCad design KiCad/GhostESP32/Rev5/GhostESP32.kicad_pcb

File KiCad/GhostESP32/Readme.md:

# GhostESP32

These notes are for a new PCB, which is based around the ESP-WROOM-32 module.

#### ESP-WROOM-32
* Wifi @ 150Mbps
* Bluetooth
* 2 CPU cores @ 80-240 MHz
* Sleep current < 5uA
* freeRTOS OS with LWIP;TLS 1.2
* Over-the-air (OTA) upgrade support
* Voltage 2.2-3.6V

Board: 2 copper layers, 70.0 x 43.0 mm, 50 parts (0 on the bottom side), 44 nets.

Parts:
C1, C2, C3, C5: 10uF; C_0402
C4, C6, C9, C10: 100nF; C_0402
C7: 100uF; C_0402
C8, C12: 1uF; C_0402
C11: 10nF; C_0402
D1, D2, D3: ESD; D_0603
D4, D5: Schottky; D_SMA
D6: GREEN; D_0603
D7: YELLOW; D_0603
J1: USB_OTG; USB_Micro-B
J2, J3: CONN_01X12; Pin_Header_Straight_1x12_Pitch2.54mm
J4: STEERING; Pin_Header_Straight_1x03_Pitch2.54mm
J5: MOTOR; Pin_Header_Straight_1x03_Pitch2.54mm
Q1, Q2, Q3: Q_NPN_BEC; SOT-23
Q4, Q5: BSS138; SOT-23
R1, R2, R15: 12k; R_0402
R3, R4: 68; R_0402
R5, R9, R10, R11, R12, R13, R14: 10k; R_0402
R6: 1k; R_0402
R7: 330; R_0402
R8: 470; R_0402
SW1: SW_SPDT; SlideSwitchSpringReturn
U1: NCP1117-3.3_SOT223; SOT-223-3Lead_TabPin2
U2: CP2102; QFN-28-1EP_5x5mm_Pitch0.5mm
U3: TMP102; SOT563
U4: MPU-9250; QFN-24-1EP_3x3mm_Pitch0.4mm
U5: ESP-WROOM-32; ESP32-WROOM

Connections:
+3V3: C2.1, C3.1, C4.1, C7.1, C8.1, C9.1, C11.1, J2.1, J3.1, Q4.1, Q5.1, R7.1, R9.1, R10.1, R13.1, R14.1, R15.1, U1.2, U2.6, U2.7, U3.5, U4.1, U4.8, U4.9, U4.13, U4.22, U5.2
+5V: C1.1, D4.1, D5.1, J3.2, J4.2, R6.1, R11.1, R12.1, U1.3
+5V_ESC: D4.2, J5.2
DTR: Q2.3, R1.2, U2.28
EN: C12.1, Q1.3, R15.2, SW1.3, U5.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D1.2, D2.2, D3.2, D6.1, J1.5, J1.6, J2.12, J3.3, J3.12, J4.3, J5.3, Q3.2, SW1.2, U1.1, U2.3, U2.29, U3.2, U3.4, U4.11, U4.18, U4.20, U5.1, U5.15, U5.38, U5.39
I34: J2.9, U5.6
I35: U4.12, U5.7
I36: J2.11, U5.4
I39: J2.10, U3.3, U5.5
IO0: Q2.2, U5.25
IO4: J3.4, U5.26
IO13: J2.3, U5.16
IO14: J2.2, U5.13
IO16: J3.5, U5.27
IO17: J3.6, U5.28
IO18: J3.7, U5.30
IO19: J3.8, U5.31
IO21(SDA): J3.9, R14.2, U3.6, U4.24, U5.33
IO22(SCL): J3.10, R13.2, U3.1, U4.23, U5.36
IO23: R5.2, U5.37
IO25: J2.6, U5.10
IO26: J2.5, Q4.2, R9.2, U5.11
IO27: J2.4, Q5.2, R10.2, U5.12
IO32: J2.8, U5.8
IO33: J2.7, U5.9
LED: D7.1, J3.11, Q3.3
MOTOR_5V_PWM: J5.1, Q5.3, R12.2
unnamed: C10.1, U4.10
unnamed: D2.1, J1.3, R3.2
unnamed: D3.1, J1.2, R4.2
unnamed: D6.2, R6.2
unnamed: D7.2, R7.2
unnamed: Q1.1, R1.1
unnamed: Q2.1, R2.1
unnamed: Q3.1, R5.1
unnamed: R3.1, U2.4
unnamed: R4.1, U2.5
unnamed: R8.2, U2.26
RTS: Q1.2, R2.2, U2.24
RXD: U2.25, U5.35
STEERING_5V_PWM: J4.1, Q4.3, R11.2
TXD: R8.1, U5.34
VBUS: C5.1, C6.1, D1.1, D5.2, J1.1, U2.8

## KiCad design KiCad/GhostSensorboard/Rev5/GhostSensorBoard/GhostSensorBoard.kicad_pcb

File KiCad/Readme.md (part):

# Custom PCBs for Ghost

### PCBs

The bottom board, the GhostESP32, contains primarily the ESP32, a micro USB, an MPU-9250 and connectors.

The top board, the GhostSensorboard, contains primarily connectors for all the sensors, servos, power, startmodule, etc.

In the first revision it used the "Sick of Beige" 50x50 formfactor, but in the second revision this has been reduced to the slightly smaller 60x37 formfactor. Also, in the second revision the accelerometer/gyro and compass has been moved from the top board to the bottom board.

The electronics use two boards that are connected together using a Hirose FX8C connector.

There is a KiCad footprint for the Hirose FX8C-60 pin connector at: https://github.com/librespacefoundation/lsf-kicad-libs
and Sick-of-beige layout from https://github.com/TomKeddie/openscad-scripts

#### PCB - GhostESP32 (Microcontroller)

- [x] ESP-WROOM-32
- [x] MicroUSB
- [x] USB-to-UART (CP2102)
- [x] Power LED
- [x] Reset buttons for ESP-WROOM-32 (Reset)
- [x] Accelerometer/Gyro/Compass (MPU-9250)
- [x] Temperature (TMP102)
- [x] Connector for ESC/Motor
- [x] Connector for Steering servo

##### PCB - GhostSensorboard (Sensors and connectors)

- [x] I2C multipexer (TCA9548ARGER, 2pcs)
- [x] 16 connectors for I2C/IR sensors
- [ ] RGB LED
- [x] Connector for Startmodule
- [x] 3V3->5V level shifter (BSS138, see Sparkfun)

### Rev 6 (future)

#### Changes from Rev 5 to Rev 6
- [ ] Fix schematic for Q2. Pins 2 and 3 are switched.
- [ ] Use Sick-of-beige 60x37
- [ ] Change footprint for the 100uF capacitors to a bigger one?
- [ ] CP2102, remove the resistors for D- and D+
- [ ] Make sure the capacitors for MPU9250, CP2102 and ESP32 as placed close to the chip.
- [ ] CP2102, Add 4.7k pullup resistor to 3V3 on RST pin
- [ ] Replace CP2102 with CP2102N (faster, pin compatible, might require two more resistors)
- [ ] Make the CP210N bus-powered. No need to power it except when programming via USB. 
(see https://www.silabs.com/documents/public/application-notes/an976-cp2102-3-4-9-to-cp2102n-porting-guide.pdf)
Add 22.1k and 47.5k voltage divider.
- [ ] Replace slide switch with side switch, f.inst: 131-6979
- [ ] Smaller 3V3 regulator. How much current do we draw at most?
- [ ] Ability to measure battery voltage. (LTC2943CDD, 2366039)
- [ ] Change resistors and capacitors 0402 to 0603.
- [ ] Fix footprint for TMP102 on Ghost Sensorboard

### Rev 5 (18.mar 2018)

Formfactor: Sick-of-beige 70x43

#### Notes and workarounds
- The Q2 schematic is wrong. Pins 2 and 3 are switched.

#### New/Changes
- [x] Fix footprint for TMP102. Was too big on Rev4.
- [-] Figure out why MPU9250 doesn't work on Rev4.
- [-] Test I2C and IR sensors on Rev4
- [-] Test the NanoPixels on Rev4
- [-] Test the Motor/ESC pwm and Steering PWM
- [x] Change to the slightly bigger TCA9548 chip for easier soldering?
- [x] Minor layout adjustments; Move Q1, Q2, R1, R2 between CP2102 and ESP32
- [x] Minor layout adjustments; Move R15 and C12 closer to SW1 switch
- [x] Remove the NanoPixels
- [x] Change I2C to use pins 21 (SDA) and 22 (SCL)
- [x] Changed I2C pullups from 2k2 to 10k
- [x] Change PCB outline to a rectangle with rounded corners
- [x] Change MPU9250 to use I2C addr 0x69, instead of 0x68

### Rev 4 (aug 2017)

Formfactor: ca 63x43mm with "drone arms"
Had wrong footprint for TMP102.

- [x] Replace MPU6050 and HMC5883 with a MPU9250
- [x] Remove the TX/RX leds and BSS138 opamps
- [x] Remove the FX8 connectors
- [x] Breakout more of the pins from ESP32 to headers
- [x] Add JTAG header for ESP32
- [x] All resistors and capacitors should use footprint 0402.
- [x] Simplified components around reset switch
- [x] ESD protection (Farnell: 238-3318)
- [x] USB resistors on D+ and D-
- [x] Temperature sensor (TMP102)

### Rev 3 (never built??)

### Rev 2 (mars 2017)

Used formfactor Sick-of-beige 60x37

### Rev 1 (feb 2017)

Used formfactor Sick-of-beige 50x50.

### Other

Sensor board:
- [x] Add 5V regulator to go from VBAT to +5V
- [ ] Is the button on Sensorboard tall enough? (And do we need it?)
- [ ] Add motor driver (MCP8063? DRV10970?)
- [x] Put an LED in each corner of the Ghost Sensorboard.
- [ ] TCA9548ARGER has wrong footprint. Needs one with thermal GND pad.
- [x] Connect battery directly to top board
- [x] Add on/off switch (MFP106D, 807527)
- [ ] Remove the IR receiver?
- [x] (alt: replace IR sensor with one in stock)
- [x] All resistors and capacitors should use footprint 0402
- [x] Add NeoPixel nano RGB leds
- [x] Remove 8 of the IR sensors connectors + one I2C mux to save space

PCB
- [ ] Move motor and steering connectors away from ESP32 on other board
- [x] Typo. Steering is mistakenly written as Start.
- [x] 6mm keepout around the mounting holes, see Sick of Beiges specs
- [x] Ground area used by U12+P3 is not connected to rest of board!
- [ ] 4-layer board
- [x] Make sure no GND plane under MPU-9250, see https://github.com/kriswiner/MPU9250/issues/43

### Others

Arduino code for the Startmodule-remote is here:
http://p1r.se/startmodule/implement-yourself/#comment-1271

------- OLD BELOW ----------

### Schematic

- [x] Startmodule pins are wrong order!! Should be VCC, GND, Start
- [x] Add two buttons for ESP-WROOM-32
- [x] Change to TCA9548ARGER (smaller footprint than TCA9548APWR)
- [x] Change from 0805 to 0603 size for capacitors, resistors and leds.
- [x] Remove extra PWM pins?
- [x] Change pin headers around so that pin 1 (the square) is GND
- [x] Use resistor array for IR sensor resistors
- [x] Red LED is always on. Figure out why. (was Q1 pins switched)
- [x] Change the Q1 transistor schematic component to use Q_NPN_BEC
- [x] Add 6 pin header for FTDI Basic, for programming ESP8266
- [ ] Remove LED strip connector?
- [ ] Add connectors to breakout ESP-WROOM-32 pins?
- [ ] Micro USB for programming ESP-WROOM-32s
- [ ] CP2102 (or similar USB-to-UART bridge)
- [ ] Use the new 47uF or 100uF alu caps?
- [ ] Use the new resistor networks?

##### Board/layout
- [ ] Current size is about 90mm x 63mm. Try to reduce to "Sick of Beige" size 80x49 or 70x43.
- [ ] Make sure I have four mountingholes for acrylic cover
- [ ] Startmodule header needs indicator for direction
- [ ] Put all pin headers on the border of the PCB
- [ ] Fix missing trace between R7 and D3(red)
- [ ] Move LEDs to a more visible place. They are under Teensy USB now.
- [ ] Move MPU-6050 to the center of the board.
- [ ] Make sure antenna part of ESP-WROOM-32 sticks outside board.

#### Car
- [X] Fix wireposition on steering servo
- [ ] Change the steering servo
- [ ] Mount wheel encoder
- [ ] Create mount for IR sensors
- [ ] Figure out which battery to use
- [ ] Mount new motor.
- [ ] Figure out the gears for the motor

#### Other
- [ ] Draw acrylic cover for PCB in OpenSCAD
- [ ] Laser-cut an acrylic cover for PCB
- [ ] Use 0.1 ohm 1% 2W current sense resistor for the INA219. Find part at Farnell.

## Bill of materials / Partlist

### RC car

## PCB Features

### Teensy 3.1/3.2 (external)

Uses a standard Teensy 3.2 board from pjrc.com.

The Teensy is based around a MK20DX256VLH7, an ARM Cortex-M4 at 72MHz. It contains 2k EEPROM where the car's configuration is stored.

In later versions I'm planning on incorporating a custom Teensy directly into the PCB. If so, then I can remove the MIC5219-3.3, since the Teensy also comes with a 3.3V regulator.

### HM-11 bluetooth

Revision 1 has both Bluetooth and WiFi. This version is for determining if BT or WiFi is easiest to work with. Later versions will only have one of the two.

It is not allowed to remotely control the car during the Folkrace, but the BT/WiFi functionality is very useful during debugging and experimentation. It allows receiving telemetry data during racing, and makes it easy to change configuration without reprogramming entire Teensy.

### ESP8266 WiFi

An ESP-12E.
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
Board: 2 copper layers, 70.0 x 43.0 mm, 48 parts (0 on the bottom side), 36 nets.

Parts:
C1: 1nF; C_0603_1608Metric
C2: 2.2uF - 10uF; C_0603_1608Metric
D1, D2, D3, D4: LED; LED_0603_1608Metric
J1: Li-Po BATTERY; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J3, J4: Conn_01x12; PinHeader_1x12_P2.54mm_Vertical
R1: 2k2; R_0402_1005Metric
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: 1k; R_0402_1005Metric
R18, R19, R20, R21: 330; R_0402_1005Metric
R22: 470; R_0402_1005Metric
R23: 270; R_0402_1005Metric
R24: 10k; R_0402_1005Metric
SW1: SW_Push; SW_SPST_EVQP2
SW2: SW_SPDT; MFP106D
U1: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm
U2, U3, U4, U5, U6, U7, U8, U9: GP2Y0E02B; JST_SH_BM04B-SRSS-TB_1x04_P1.00mm_Vertical
U10: Transmissive_Photo_Interrupter; PinHeader_1x04_P2.54mm_Vertical
U11: TMP102; SOT-23-6
U12: MIC5219-5.0; SOT-23-5

Connections:
+3V3: J3.1, J4.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.2, R19.2, R20.2, R21.2, U1.24, U2.4, U3.4, U4.4, U5.4, U6.4, U7.4, U8.4, U9.4, U11.4, U11.5
+5V: C2.1, J4.2, R23.2, R24.1, U12.5
+BATT: SW2.1, U12.1, U12.3
BUTTON: J4.7, R22.2
ENCODER: J4.8, R24.2, U10.3
GND: C1.1, C2.2, J1.2, J2.2, J3.12, J4.3, J4.12, SW1.2, U1.1, U1.2, U1.12, U1.21, U2.3, U3.3, U4.3, U5.3, U6.3, U7.3, U8.3, U9.3, U10.2, U10.4, U11.2, U12.2
I36: J3.11, U11.3
IO13: J2.1, J3.3
IO21(SDA): J4.9, U1.23, U11.6
IO22(SCL): J4.10, U1.22, U11.1
IO25: J2.3, J3.6
LED: D1.1, D2.1, D3.1, D4.1, J4.11
unnamed: C1.2, R22.1, SW1.1
unnamed: D1.2, R18.1
unnamed: D2.2, R19.1
unnamed: D3.2, R20.1
unnamed: D4.2, R21.1
unnamed: J1.1, SW2.2
unnamed: R1.2, U1.3
unnamed: R23.1, U10.1
SC0: R3.2, U1.5, U2.1
SC1: R5.2, U1.7, U3.1
SC2: R7.2, U1.9, U4.1
SC3: R9.2, U1.11, U5.1
SC4: R11.2, U1.14, U6.1
SC5: R13.2, U1.16, U7.1
SC6: R15.2, U1.18, U8.1
SC7: R17.2, U1.20, U9.1
SD0: R2.2, U1.4, U2.2
SD1: R4.2, U1.6, U3.2
SD2: R6.2, U1.8, U4.2
SD3: R8.2, U1.10, U5.2
SD4: R10.2, U1.13, U6.2
SD5: R12.2, U1.15, U7.2
SD6: R14.2, U1.17, U8.2
SD7: R16.2, U1.19, U9.2

## KiCad design KiCad/GhostESP32/Rev3/GhostESP32.kicad_pcb

Parts:
C1, C2, C3, C7: 10uF; C_0402
C4: 100uF; C_0402
C5, C8, C11, C12: 0.1uF; C_0402
C6, C10: 1uF; C_0402
C13: 10nF; C_0402
D1: GREEN LED; LED_0603
D2: LED; LED_0603
D3, D4, D6: ESD; D_0603
D5: SSA33L Schottky; D_SMA
J1: CONN_02X05; Pin_Header_Straight_2x05_Pitch1.27mm_SMD
J2: USB_OTG; USB_Micro-B
J3: CONN_01X14; Pin_Header_Straight_1x14_Pitch2.54mm
J4: CONN_01X10; Pin_Header_Straight_1x10_Pitch2.54mm
Q1, Q2, Q3: Q_NPN_BEC; SOT-23
R1: 2K; R_0402
R2: 390; R_0402
R3, R4, R11: 12K; R_0402
R5, R6: 68; R_0402
R7: 470; R_0402
R8, R9: 2k2; R_0402
R12: 10k; R_0402
SW1: SW_SPDT; SlideSwitchSpringReturn
U1: MPU-9250; QFN-24_3x3mm_Pitch0.4mm
U2: NCP1117ST33T3G; SOT-223-3Lead_TabPin2
U3: CP2102; QFN-28-1EP_5x5mm_Pitch0.5mm
U4: ESP-WROOM-32; ESP32-WROOM
U5: TMP102; SOT563

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C11.1, C13.1, J1.1, J3.3, R2.2, R8.1, R9.1, R11.1, U1.1 (RESV), U1.8 (VDDIO), U1.13 (VDD), U1.22 (~CS), U2.2 (VO), U3.6 (VDD), U3.7 (REGIN), U4.2 (3V3), U5.5 (V+)
+BATT: C1.1, D5.1 (K), J3.1, R1.1, U2.3 (VI)
DTR: Q2.2 (E), R3.2, U3.28 (DTR)
EN: C10.1, J3.14, Q1.3 (C), R11.2, SW1.3 (C), U4.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, D1.1 (K), D3.2 (A), D4.2 (A), D6.2 (A), J1.3, J1.5, J1.7, J1.9, J2.5 (GND), J2.6 (Shield), J3.2, J4.10, Q3.2 (E), SW1.2 (B), U1.9 (AD0/SDO), U1.11 (FSYNC), U1.18 (GND), U1.20 (RESV), U2.1 (GND), U3.3 (GND), U3.29 (GND), U4.1 (GND), U4.15 (GND), U4.38 (GND), U4.39 (GND-PAD), U5.2 (GND), U5.4 (ADD0)
I34: J3.11, U4.6 (IO34)
I35: U1.12 (INT), U4.7 (IO35)
I36: J3.13, U4.4 (SENSOR_VP)
I39: J3.12, U4.5 (SENSOR_VN), U5.3 (ALERT)
IO0: Q2.3 (C), U4.25 (IO0)
IO4: J4.3, U4.26 (IO4)
IO12: J1.8, U4.14 (IO12)
IO13: J1.4, J3.10, U4.16 (IO13)
IO14: J1.2, J3.9, U4.13 (IO14)
IO15: J1.6, U4.23 (IO15)
IO16: J4.4, U4.27 (IO16)
IO17: J4.5, U4.28 (IO17)
IO18: J4.6, U4.30 (IO18)
IO19: J4.7, U4.31 (IO19)
IO21: J4.8, U4.33 (IO21)
IO22: J4.9, U4.36 (IO22)
IO23: R12.1, U4.37 (IO23)
IO25: J3.6, U4.10 (IO25)
IO26: J3.5, U4.11 (IO26)
IO27: J3.4, U4.12 (IO27)
IO32/SCL: J3.8, R8.2, U1.23 (SCL), U4.8 (IO32), U5.1 (SCL)
IO33/SDA: J3.7, R9.2, U1.24 (SDA), U4.9 (IO33), U5.6 (SDA)
LED: D2.1 (K), J4.2, Q3.3 (C)
unnamed: C12.1, U1.10 (REGOUT)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.1
unnamed: D4.1 (K), J2.3 (D+), R5.2
unnamed: D6.1 (K), J2.2 (D-), R6.2
unnamed: Q1.1 (B), R3.1
unnamed: Q2.1 (B), R4.1
unnamed: Q3.1 (B), R12.2
unnamed: R7.1, U3.26 (TXD)
RTS: Q1.2 (E), R4.2, U3.24 (RTS)
RXD: U3.25 (RXD), U4.35 (TXD0)
TXD: R7.2, U4.34 (RXD0)
USB_DN: R6.1, U3.5 (D-)
USB_DP: R5.1, U3.4 (D+)
VBUS: C7.1, C8.1, D3.1 (K), D5.2 (A), J2.1 (VBUS), J4.1, U3.8 (VBUS)

Notes on the sheet:
Ghost ESP32 Rev 3
A board based around the ESP-WROOM-32 It uses a stackable header from Hirose to connect to other boards. Board is powered by 5.0V either through MicroUSB, or via 40-pin connector.
MMBT2222A NPN transistors Farnell no: 177-3626
Generic LED (Red)
MicroUSB Farnell no: 229-3836
NCP1117ST33T3G Farnell no: 165-2366 1.07V dropout, 1A out
Note, GPIO 34 - 39 are INPUT mode ONLY. Note, GPIO 6-11 are used by SPI-flash, and cannot be used for other purposes. Note, GPIO0, GPIO2, GPIO5, GPIO12 and GPIO15 are strapping pins, and cannot be pulled high/low. Note, GPIO23 dedicated to LED Note, GPIO32 and GPIO33 is dedicated to I2C
Reset button for ESP32 Farnell no: 152-2053 (alt: 152-2052)
Strapping pins. Use with caution. Do not pull high/low.
I2C pull-ups
MMBT2222A (alt MB3904) Farnell no: 177-3626 (177-3602)
MPU-9250 MEMS (acc/gyro/compass) Farnell no: ???-???? I2C-address: 0x68 (0x69 if AD0 high)
CP2102 USB interface Farnell no: 928-2130
Two 0.1" header rows Each pin max 3A current NB, 34, 36, 39 are Input-only One side shorter than other to make room for reset button.
JTAG
Batt (3.5V - 20V)
ESD suppressors Farnell no: 238-3318
TMP102 temperature I2C address: 0x48 Farnell no: 165-2477

Board: 2 copper layers, 60.0 x 37.0 mm, 42 parts (0 on the bottom side), 43 nets.

## KiCad design KiCad/GhostSensorboard/Rev3/GhostSensorboard.kicad_pcb

Board: 2 copper layers, 60.0 x 37.0 mm, 63 parts (0 on the bottom side), 44 nets.

Parts:
BT1: Battery_Cell; Pin_Header_Straight_1x02_Pitch2.54mm
C1: 1uF; C_0402
C2: 1nF; C_0402
C3: 2.2uF-10uF; C_0402
C4: 0.1uF; C_0402
D1, D2, D3, D4: LED; LED_0603
J1: CONN_01X14; Pin_Header_Straight_1x14_Pitch2.54mm
J2: CONN_01X10; Pin_Header_Straight_1x10_Pitch2.54mm
P1: StartModule; Pin_Header_Straight_1x03_Pitch2.54mm
P2: SteeringServo; Pin_Header_Straight_1x03_Pitch2.54mm
P3: Motor; Pin_Header_Straight_1x03_Pitch2.54mm
Q1, Q2: BSS138; SOT-23
R1, R11, R12: 2k2; R_0402
R2: 33-1k ohm; R_0402
R3, R6, R7, R8, R15: 10k; R_0402
R4: 470; R_0402
R5, R16, R17, R18: 330; R_0402
R9, R10, R13, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31: 1k; R_0402
R14: 270; R_0402
SW1: SW_Push; SW_SPST_EVQP2
SW2: SW_SPDT; MFP106D
U1: TCA9548ARGER; QFN-24_4x4mm_Pitch0.5mm_NoMask
U2, U3, U7, U8, U10, U11, U12, U13: GP2Y0E02B; JST_SH_BM04B-SRSS-TB_04x1.00mm_Straight
U4: TSOP752-TSOP754; TSOP75x
U5: Transmissive_Photo_Interrupter; Pin_Header_Straight_1x04_Pitch2.54mm
U6, U9: NeoPixelNano
U14: MIC5219-5.0; SOT-23-5

Connections:
+3V3: J1.3, Q1.1, Q2.1, R1.1, R2.2, R3.1, R5.2, R7.1, R9.1, R10.1, R11.1, R12.1, R13.1, R16.2, R17.2, R18.2, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, U1.21, U2.4, U3.4, U7.4, U8.4, U10.4, U11.4, U12.4, U13.4
+5V: C3.1, C4.1, P2.2, P3.2, R6.1, R8.1, R14.2, R15.1, U6.4, U9.4, U14.5
+BATT: J1.1, SW2.1, U14.1
BUTTON: J2.6, R4.2
ENABLE5V: J2.8, U14.3
ENCODER: J2.7, R15.2, U5.3
GND: BT1.2, C1.2, C2.1, C3.2, C4.2, J1.2, J2.10, P1.2, P2.3, P3.3, SW1.2, U1.9, U1.18, U1.22, U1.23, U2.3, U3.3, U4.1, U4.4, U5.2, U5.4, U6.2, U7.3, U8.3, U9.2, U10.3, U11.3, U12.3, U13.3, U14.2
IO16: J2.4, U6.3
IO17: J2.5, P1.1
IO22: J2.9, U4.3
IO25: J1.6, P1.3
IO26: J1.5, Q1.2, R3.2
IO27: J1.4, Q2.2, R7.2
IO32/SCL: J1.8, R1.2, U1.19
IO33/SDA: J1.7, R11.2, U1.20
LED: D1.1, D2.1, D3.1, D4.1, J2.2
MOTOR_5V_PWM: P3.1, Q2.3, R8.2
unnamed: BT1.1, SW2.2
unnamed: C1.1, R2.1, U4.2
unnamed: C2.2, R4.1, SW1.1
unnamed: D1.2, R5.1
unnamed: D2.2, R16.1
unnamed: D3.2, R17.1
unnamed: D4.2, R18.1
unnamed: R12.2, U1.24
unnamed: R14.1, U5.1
unnamed: U6.1, U9.3
SC0: R10.2, U1.2, U2.1
SC1: R19.2, U1.4, U3.1
SC2: R21.2, U1.6, U7.1
SC3: R23.2, U1.8, U8.1
SC4: R25.2, U1.11, U10.1
SC5: R27.2, U1.13, U11.1
SC6: R29.2, U1.15, U12.1
SC7: R31.2, U1.17, U13.1
SD0: R9.2, U1.1, U2.2
SD1: R13.2, U1.3, U3.2
SD2: R20.2, U1.5, U7.2
SD3: R22.2, U1.7, U8.2
SD4: R24.2, U1.10, U10.2
SD5: R26.2, U1.12, U11.2
SD6: R28.2, U1.14, U12.2
SD7: R30.2, U1.16, U13.2
STEERING_5V_PWM: P2.1, Q1.3, R6.2

## KiCad design KiCad/GhostESP32/Rev2/GhostESP32.kicad_pcb

Board: 2 copper layers, 60.0 x 37.0 mm, 44 parts (0 on the bottom side), 46 nets.

Parts:
C1, C2, C3, C7: 10uF; C_0603
C4: 100uF; C_0603
C5, C8, C11: 0.1uF; C_0603
C6: 1uF; C_0603
C9, C10: 1nF; C_0603
C12: 10nF; C_0603
C13: 2.2nF; C_0603
C14: 0.22uF; C_0603
C15: 4.7uF; C_0603
D1: RED LED; LED_0603
D2: LED; LED_0603
D3: RXLED; LED_0603
D4: TXLED; LED_0603
D5: SSA33L Schottky; D_SMA_Standard
J1: CONN_02X20; hrs-fx8c-40p-sv
P1: USB_OTG; USB_Micro-B
Q1, Q2, Q3: Q_NPN_BEC; SOT-23
R1: 2K; R_0603
R2: 390; R_0603
R3, R4, R11: 12K; R_0603
R5, R6: 1k; R_0603
R7, R10: 470; R_0603
R8, R9: 2k2; R_0603
R12: 10k; R_0603
SW1: SW_SPDT; SlideSwitchSpringReturn
U1: LM358; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: NCP1117ST33T3G; SOT-223-3Lead_TabPin2
U3: CP2102; QFN-28-1EP_5x5mm_Pitch0.5mm
U4: ESP-WROOM-32; ESP32-WROOM
U5: MPU-6050; QFN-24-1EP_4x4mm_Pitch0.5mm
U6: HMC5883; QFN-16-1EP_3x3mm_Pitch0.5mm

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C12.2, J1.7, J1.8, J1.9, J1.10, R2.2, R8.1, R9.1, R11.1, U1.8, U2.2, U3.6, U3.7, U4.2, U5.8, U5.13, U6.2, U6.4, U6.13
+5V: C1.1, C7.1, C8.1, D5.1, J1.35, J1.36, J1.37, J1.38, J1.39, J1.40, R1.1, U2.3, U3.8
DTR: Q2.2, R3.2, U3.28
EN: C10.1, Q1.3, R10.1, R11.2, U4.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C15.1, D1.1, D3.1, D4.1, J1.13, J1.14, J1.15, J1.16, J1.17, J1.18, J1.19, J1.20, P1.5, P1.6, Q3.2, SW1.2, U1.4, U2.1, U3.3, U3.29, U4.1, U4.15, U4.38, U4.39, U5.1, U5.9, U5.11, U5.18, U6.9, U6.11
IO0: Q2.3, U4.25
IO4: J1.28, U4.26
IO13: J1.33, U4.16
IO14: J1.34, U4.13
IO16: J1.27, U4.27
IO17: J1.26, U4.28
IO18: J1.25, U4.30
IO19: J1.24, U4.31
IO21: J1.23, U4.33
IO22: J1.22, U4.36
IO23: R12.2, U4.37
IO25: J1.3, U4.10
IO26: J1.2, U4.11
IO27: J1.1, U4.12
IO32: J1.5, R9.2, U4.8, U5.23, U6.1
IO33: J1.4, R8.2, U4.9, U5.24, U6.16
IO34: U4.6, U6.15
IO35: U4.7, U5.12
LED: D2.1, J1.21, Q3.3
unnamed: C9.1, R10.2, SW1.3
unnamed: C11.2, U5.10
unnamed: C13.2, U5.20
unnamed: C14.1, U6.12
unnamed: C14.2, U6.8
unnamed: C15.2, U6.10
unnamed: D1.2, R1.2
unnamed: D2.2, R2.1
unnamed: D3.2, R6.1
unnamed: D4.2, R5.1
unnamed: D5.2, P1.1
unnamed: Q1.1, R3.1
unnamed: Q2.1, R4.1
unnamed: Q3.1, R12.1
unnamed: R5.2, U1.1, U1.2
unnamed: R6.2, U1.6, U1.7
unnamed: R7.1, U3.26
RTS: Q1.2, R4.2, U3.24
RXD: U1.5, U3.25, U4.35
TXD: R7.2, U1.3, U4.34
USB_DN: P1.2, U3.5
USB_DP: P1.3, U3.4

## Commit log

2016-05-27 Started on Schematic
2016-05-28 Added IMU
2016-06-06 Lots of changes
2016-06-20 Fixed mounting holes.
2016-07-15 Started on Feature Tests in Arduino
2016-07-17 Minor
2016-07-19 Some info, rev 1 printout, feature test code
2016-07-19 Working on WiFi
2016-07-22 ESP8266 can connect to WiFi
2016-07-23 MPU-6050 works. IR-sensors needs more testing.
2016-07-23 Steering servo works
2016-07-24 Identified transistor mixup
2016-07-25 XC-10A ESC works
2016-07-25 Testing delay times for ESC
2016-07-31 Minor. Started on lasercut part.
2016-08-04 Started on PCB rev 2
2016-08-04 Working on PCB layout for Rev 2
2016-08-05 Resistor
2016-10-17 Added PCB mount
2016-10-23 Improved Steering testcode
2016-10-25 PCB-mount lasercut
2016-10-26 Minor testing
2016-10-29 Adding PID
2016-10-29 Testing PID
2016-10-31 Playing around with PID
2016-11-02 Driving is actually not bad!
2016-11-02 Started organizing code
2016-11-11 VS formatting
2016-11-11 Playing around
2016-11-11 Playing around with Steering and .cpp
2016-11-12 Started using front sensors
2016-11-12 Fixed steering compensation
2016-11-12 Not good at all...
2016-12-04 Minor changes.
2016-12-07 Replacing Teensy with ESP8266
    Changes made on KiCad on Ubuntu
2016-12-07 Playing around with ROS and Gazebo
2016-12-07 Creating folder for documentation and images
2016-12-07 Testing Pages in GitHub
2016-12-09 Got a very basic world working
2016-12-09 Minor docs
2016-12-13 Minor changes
2016-12-14 Python simulator
2016-12-14 Testing
2016-12-14 Simple robot
2016-12-15 Testing C++
2017-01-29 Testing ROS
2017-01-29 Testing more ROS
2017-01-29 Switching to ESP-WROOM-32
2017-02-01 Working on USB
2017-02-01 More related to USB
2017-02-02 Created GhostESP32 shield schematics
2017-02-04 Starting on ESP32 software
2017-02-04 Working on Steering for ESP32. Doesn't work yet.
    Maybe because the servo is 5V, but output from ESP is 3.3V?
2017-02-05 Added Ghost Sensorboard schematics
2017-02-06 Started routing the GhostESP32 board
2017-02-07 Spent hours doing routing...
2017-02-13 Started on a lasercut sensorframe
2017-02-21 GhostESP32 and GhostSensorboard mostly done - but with wrong 60 pin connector
2017-02-25 Routing finished. Playing around with BOM as XSL file.
2017-02-25 Both boards done, and sent to Elecrow.
2017-02-25 Working on the first simple ESP32 programs
2017-02-25 Testing GitKraken
2017-02-26 Comments about pins 34-39 and 6-11.
2017-02-26 Trying to get button-to-led program to work. Doesn't yet.
2017-02-26 Eclipse configured
2017-02-26 Button-to-led works
2017-02-26 About to replace code
2017-02-26 Startmodule program works!
2017-02-27 Startmodule connected to GPIO instead of 3V3 for software power recycle. Motor-pwm connected to IO25 instead of IO34 (which is input only) DRDY connected to IO33 instead of IO35 (which is input only)
2017-02-27 Refactored startmodule to separate file.
2017-02-27 Started on IRSensor testprogram
2017-02-28 I2Cscanner works after adjusting timeout. Started on a TMP102 driver.
2017-02-28 A little further along with the TMP102 device
2017-03-01 Can get temperature from tmp102 device
2017-03-01 Started on IR sensor code
2017-03-01 Error checking
2017-03-01 IRSensor could theoretically work, but not tested.
2017-03-02 Updated from esp-idf-template
2017-03-02 GP2Y0E02B works!
2017-03-03 Restructuring files
2017-03-03 Trying to get Eclipse working
2017-03-03 Removing broken project
2017-03-03 Eclipse is configured correctly
2017-03-03 Added GeneralPurposeButton project in Eclipse
2017-03-03 Trying to ignore .metadata
2017-03-03 Ignoring
2017-03-03 More ignores
2017-03-04 Servo sweeping works
2017-03-07 My Ghost ESP32 board works!
2017-03-09 Fixing sensorframe
2017-03-13 Several lasercut parts
2017-03-14 Started on Rev2 of Ghost PCBs
2017-03-14 Made a connectorboard
2017-03-16 Made encoder disc
2017-03-17 Working on the Encoder
2017-03-19 Ready to start routing. Schematics should be done.
2017-03-19 Ghost ESP32 done routing. Created Gerbers.
2017-03-20 Rev2 sent to Elecrow for production
2017-03-25 Minor adjustments
2017-03-26 Set theme jekyll-theme-cayman
2017-03-26 Notes
2017-03-26 Leftover file
2017-04-01 More notes
2017-04-07 Pins updated to match Rev2 boards
2017-04-07 Started on driver for the motor ESC
2017-04-07 Trying to get I2C to work, but it just crashes...
2017-04-07 Still doesn't work
2017-04-07 I2C scanner works
2017-04-08 Started on a MPU6050 example.
2017-04-08 Scanning finally found the U1
2017-04-08 Working on getting the TCA9548 to work.
2017-04-10 Got sensors working!
2017-04-12 Motor works
2017-04-13 Removed bad submodules
2017-04-13 Added empty project for C++
2017-04-13 Eclipse files
2017-04-13 Working on getting the C++ example better
2017-04-13 Added LED to CPlusPlus example
2017-04-16 Added Ghost32Architecture.xml
2017-04-17 Temp
2017-04-17 Implemented CarState as Singleto
2017-04-17 Playing around with StartModule
2017-04-18 Comments to ESP32
2017-04-29 Started implementing PWM class
2017-04-29 More work on the PWM class
2017-04-30 Getting an 'undefined reference'
2017-04-30 Updated esp-idf, so new lines in sdkconfig, and added Sensors dir
2017-04-30 TCA9548 has wrong footprint
2017-05-01 IR sensor at U2 works
2017-05-01 Cleaner output
2017-05-01 Playing around with sensors controlling steering
2017-05-02 Playing around with Queues
2017-05-02 More Queue testing
2017-05-03 Sensordata now passed through drivecomputer
2017-05-03 Fixed xTicksToWait
2017-05-04 Configured max and min steering values
2017-05-04 Steering basically works
2017-05-04 Basic motor control in place
2017-05-05 Lot of work on Motor
2017-05-06 Ability to enable/disable motor
2017-05-06 Did three rounds with these settings
2017-05-06 Working on calculating angle to wall
2017-05-06 Ignore
2017-05-06 More ignore
2017-05-06 Working on the wall angle compensation.
2017-05-06 Startmodule works
2017-05-06 Playing around with Wifi and sockets. Doesn't work
2017-05-06 Minor MPU6050 changes
2017-05-06 Started on detecting if I'm moving
2017-05-06 Separated some features
2017-05-07 Added SoftwareTimer example
2017-05-07 Added LED_PIN
2017-05-11 Attempting to add WebSockets over WiFi
2017-05-11 Renamed to cpp
2017-05-28 Playing around with a javascript based GCS (Ground Control Station)
2017-05-28 Adding simple Boost example. Doesn't work.
2017-05-28 Playing around with WebSockets
2017-05-28 Changes from Gøteborg
2017-05-28 PLaying around with GCS
2017-05-28 Code after watching video episode 8
2017-05-29 Auto stash before merge of "master" and "origin/master"
2017-05-30 Started on an experimental PCB
2017-06-05 Updated gitignore for node_modules
2017-06-05 Testing Arduino sketches on ESP32
2017-06-05 First go at a control station using Node.js
2017-06-06 Got I2C working together with Socket.io
2017-06-10 Working on a Mongoose OS application
2017-06-11 Add build to ignore
2017-06-11 Mongoose Readme
2017-06-11 Mongoose projects, and Visual Studio Code setup
2017-06-11 Ignore all files in build
2017-06-11 Got C++ and Startmodule working
2017-06-11 Minor change to startmodule
2017-06-12 Working on Rev3 of the Ghost ESP32 schmatics
2017-06-17 Working on Rev3 of GhostESP32
2017-06-17 Minors, probably autosaves
2017-06-17 Working on Rev3 of the sensorboard
2017-06-17 Updated readmefile
2017-06-17 Added VS Code intellisense for Linux
2017-06-17 Working on RC5/Startmodule
2017-06-19 Links
2017-06-19 Working on the RC5 statemachine
2017-06-19 StartModuleImplementation compiles
2017-06-19 Include statemachine compiles
2017-07-28 Unknown update
2017-07-28 Playing around with RC5
2017-07-28 Update to rev 3
2017-07-28 Updated 3D models
    https://forum.kicad.info/t/incorrect-component-models-in-3d-viewer/7011/15
2017-08-11 Started on Rev 4 of the ESP32 PCB
2018-02-05 A massive bunch of former changes waiting to be committed.
2018-02-07 Remote submodules
2018-02-08 Add folder
2018-02-08 Remove submodule
2018-02-08 Start new Mongoose-OS project
2018-02-08 Some basic c++ code
2018-02-08 Add skeleton for IRSensor
2018-02-08 Playing around with I2C
2018-02-09 Started on Rev5 of GhostESP32
2018-02-10 Started on PWM code
2018-02-10 Notes for Rev5
2018-02-10 VS Code settings
2018-02-10 Playing around with threads
2018-02-10 Basic Servo steering works
2018-02-10 Basic startmodule (in main.cpp) works
2018-02-11 Further playing around with StartModule
2018-02-12 Minor changes for Win32
2018-03-18 Working on revision 5 of the PCBs
2018-03-18 Rev 5 of boards sent to production
2018-03-20 StartModule compiles
    But still problem inside goto_next_state method. The properties doesn't have a value.
2018-03-24 StartModule works. Started on CarState.
2018-03-24 Printing a JSON structure works
2018-03-24 Startmodule in JSON works.
2018-03-29 Preparing several classes
2018-03-30 Changed pins to match Ghost32 rev 5
2018-03-30 Various readme comments from working with Ghost32 Rev 5
2018-03-30 Started on tmp102 driver. Doesn't compile.
2018-03-31 TMP102 sensor works
2018-04-02 Testcode for TCA9548
2018-04-02 Working on TCA9548 driver
2018-04-03 TCA9548 works. Can change channels.
2018-04-03 Button works. Still working on IR sensor.
2018-04-05 Reading IR Sensors works
2018-04-07 Distance in centimeters works
2018-04-09 Working on Point and vector math
2018-04-15 Startmodule VCC fix
2018-04-15 Started on HobbyKing XC-10A ESC driver
2018-04-15 Calibration beeps correctly
2018-04-15 Wheels are moving!
2018-04-16 Started working on sensor logic
2018-04-29 ignores
2018-04-29 vs code changes
2018-04-29 Started on MPU9250
2018-04-29 GL simulator code
2018-04-29 Used by MPU9250
2018-06-02 Docs
2018-06-02 Fix missing returntype
2018-06-02 Fix build
2018-06-16 Comments
2018-06-16 RPC call Car.Drive responds
2018-06-16 Add dummy response JSON to Car.Drive
2018-06-16 Add RPC service for Car.GetState
